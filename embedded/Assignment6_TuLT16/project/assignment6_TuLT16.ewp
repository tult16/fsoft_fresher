# IAR project assignment6_TuLT16.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VMP4
  ICCARM.CCIncludePath2: ..\MKL46Z\MKL46Z; ..\CMSIS\CMSIS\Include; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: assignment6_TuLT16.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source/App
    ../source/: App.c
  group source/Queue
    ../source/: Queue.c
  group source/Srec parse
    ../source/: SrecPase.c
  group source/UART0
    ../source/: UARTO.c
  group startup
    ../MKL46Z/MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
