# IAR project Mock2_TuLT16.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VMP4
  ICCARM.CCIncludePath2: ..\source; ..\CMSIS\CMSIS\Include; ..\MKL46Z\MKL46Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mock2_TuLT16.srec
  ILINK.IlinkOutputFile: Mock2_TuLT16.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source/BOOT
    ../source/: Boot.c Boot.h
  group source/FLASH
    ../source/: Flash.c Flash.h
  group source/QUEUE
    ../source/: updata_QUEUE.h update_QUEUE.c
  group source/SREC_PARSE
    ../source/: update_parse.c update_parse.h
  group source/UART
    ../source/: UART_driver.c UART_driver.h
  group startup
    ../MKL46Z/MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
