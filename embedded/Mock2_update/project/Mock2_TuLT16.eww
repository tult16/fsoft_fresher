<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Mock2_TuLT16.ewp</path>
    </project>
    <batchBuild />
</workspace>
