# IAR project asssignment4_TuLT16.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VMP4
  ICCARM.CCIncludePath2: ..\CMSIS\CMSIS\Include; ..\MKL46Z\MKL46Z; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: asssignment4_TuLT16.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../source/: main.c port_gpio.h
  group source/Board_setting
    ../source/: board_setting.c board_setting.h
  group source/DRIVER_adc
    ../source/: DRIVER_adc.c DRIVER_adc.h
  group source/DRIVER_gpio
    ../source/: DRIVER_gpio.c DRIVER_gpio.h
  group source/DRIVER_lcd
    ../source/: lcd.c lcd.h
  group source/HAL_gpio
    ../source/: HAL_gpio.c HAL_gpio.h
  group source/HAL_port
    ../source/: HAL_port.c HAL_port.h
  group startup
    ../MKL46Z/MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
